# Keil uVision project rukavice.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rukavice +hex
  c flags: Optim=1
  c include: ..\rukavice;.\knih;.\knih\STM32L1xx\Include;.\knih\STM32L1xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group startup
    ./: startup_stm32l1xx_md.s
  group knihovny
    ./knih/: system_stm32l1xx.c uart.c
    ./knih/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_usart.c misc.c stm32l1xx_tim.c
    ./: init.c
  group main
    ./: main.c
